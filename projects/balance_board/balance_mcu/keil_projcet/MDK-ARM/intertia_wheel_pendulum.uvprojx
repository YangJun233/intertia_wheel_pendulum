# Keil uVision project intertia_wheel_pendulum.uvprojx, settings and files
target intertia_wheel_pendulum (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: intertia_wheel_pendulum +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\..\..\..\..\..\..\..\Common_SDK\common_sdk;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\defaults_config;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\profile\battery;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\profile\debug;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\profile\device_info;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\profile\protocol;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\profile\time;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\library\driver\key;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\library\driver\led;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\library\driver\imu;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\library\driver\oled;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\library\driver\motor;..\..\..\..\..\..\..\..\Common_SDK\common_sdk\library\algorithm\pid;..\..\project_src\system_config;..\..\project_src\system_adapter;..\..\project_src\system_adapter\hardware_platform;..\..\project_src\business_logic
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/adapter
    ../../project_src/system_adapter/: system_adapter.c
    ../../project_src/system_adapter/hardware_platform/: hardware_platform_adapter.c
  group Application/business_logic
    ../../project_src/business_logic/: motor_ctrl.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group MCOM_SDK/sdk/default_config
    ../../../../../../../../Common_SDK/common_sdk/defaults_config/: defaults_config.h defaults_definitions.h
    ../../../../../../../../Common_SDK/common_sdk/: sdk_include.h
  group MCOM_SDK/sdk/profile
    ../../../../../../../../Common_SDK/common_sdk/profile/battery/: battery_profile.c
    ../../../../../../../../Common_SDK/common_sdk/profile/debug/: assert_profile.c log_profile.c printf_profile.c
    ../../../../../../../../Common_SDK/common_sdk/profile/device_info/: device_info_profile.c
    ../../../../../../../../Common_SDK/common_sdk/profile/protocol/: protocol.c
    ../../../../../../../../Common_SDK/common_sdk/profile/time/: delay_profile.c
  group MCOM_SDK/system_config
    ../../project_src/system_config/: system_config.h
  group MCOM_SDK/sdk/driver
    ../../../../../../../../Common_SDK/common_sdk/library/driver/key/: key.c
    ../../../../../../../../Common_SDK/common_sdk/library/driver/led/: led.c
    ../../../../../../../../Common_SDK/common_sdk/library/driver/imu/: mpu6050.c
    ../../../../../../../../Common_SDK/common_sdk/library/driver/motor/: motor.c
    ../../../../../../../../Common_SDK/common_sdk/library/driver/oled/: oled.c
  group MCOM_SDK/sdk/algorithm
    ../../../../../../../../Common_SDK/common_sdk/library/algorithm/pid/: pid.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 5.4.0
